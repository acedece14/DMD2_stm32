# IAR project FEDO.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; Libraries\STM32F10x_StdPeriph_Driver\inc; inc; HAL
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: FEDO.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: FEDO_plus_heap_stack.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: arial16b.h DMD2.cpp DMD2.h DMD2_Text.cpp DMD2_TextBox.cpp DMD2_Timer.cpp DMDFrame.cpp dtostrf.c dtostrf.h itoa.c itoa.h main.c pgmspace.h Print.h Printable.h TermMain.c uni8.h WString.cpp WString.h
  group HAL
    HAL/: AT45DB161.c AT45DB161.h ConfigSys.c ConfigSys.h HAL_Delay.c HAL_Delay.h hal_IO.c hal_IO.h hal_SPI.c hal_SPI.h hal_TIM2.c hal_TIM2.h hal_uart.c hal_uart.h Help_function.c Help_Function.h
    ./: TEST_LEDP.c TEST_LEDP.h
  group inc
    inc/: MyDefine.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c
  group startup
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
  group StdPeriph_Driver
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
